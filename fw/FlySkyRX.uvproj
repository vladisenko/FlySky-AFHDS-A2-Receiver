# Keil uVision project FlySkyRX.uvproj, settings and files
target RX (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: FlySkyRX +hex
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\src;.\start-up
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group start-up
    ./start-up/: system_stm32f0xx.c startup_stm32f030.s
  group src
    ./src/: main.c A7105.c dsm.c flash.c bsp.c rx_spi.c flysky_A2.c
